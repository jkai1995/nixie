# Keil uVision project nixie.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nixie +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ../System/;../CMSIS/Core;../CMSIS/Driver;../Lib/STM32F1xx_DFP/2.3.0/RTE_Driver/Config;../Lib/STM32F1xx_DFP/2.3.0/RTE_Driver;../Lib\STM32F1xx_DFP/2.3.0/Device/StdPeriph_Driver/inc;../Core/letter-shell;../FreeRTOS/include;../FreeRTOS/port/ARM_CM3;../board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/: main.c powerCtrl.c powerCtrl.h shellPort.c shellPort.h bluetooth.c bluetooth.h usartDriver.c usartDriver.h ds3231.c ds3231Port.c ds3231.h ds3231Port.h i2cDriver.c i2cDriver.h realtimeCtrl.c realtimeCtrl.h
  group board
    ../board/: 74HC595.c 74HC595.h spiDriver.c spiDriver.h
  group System
    ../System/: stm32f10x_it.c stm32f10x_it.h
  group letter_shell
    ../Core/letter-shell/: shell.c shell.h shell_cfg.h shell_cmd_list.c shell_companion.c shell_ext.c shell_ext.h
  group FreeRTOS-port
    ../FreeRTOS/port/ARM_CM3/: port.c portmacro.h
  group FreeRTOS
    ../FreeRTOS/: tasks.c timers.c list.c queue.c
    ../FreeRTOS/port/MemMang/: heap_4.c
  group CMSIS
    ../CMSIS/Core/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm3.h
  group stm32f1xx-system
    ../Lib/STM32F1xx_DFP/2.3.0/Device/Source/: system_stm32f10x.c
    ../Lib/STM32F1xx_DFP/2.3.0/Device/Source/ARM/: startup_stm32f10x_md.s
    ../Lib/STM32F1xx_DFP/2.3.0/Device/Include/: stm32f10x.h system_stm32f10x.h
  group stm32f1xx-Driver
    ../Lib/STM32F1xx_DFP/2.3.0/RTE_Driver/: GPIO_STM32F10x.c GPIO_STM32F10x.h
    ../Lib/STM32F1xx_DFP/2.3.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_spi.c
